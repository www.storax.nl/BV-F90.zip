Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: d7b50f96-327e-4f24-8df6-e89bb878915d.ifc
Time: 2026-08-11T11:33:17
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd brandwerend enkel, uitneembaar Storax - BV-F90 110, 1000x1000mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 120 min; Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAJo--bYDAAAAb-wCAAV2SgAAlV8BAFJfAQCe7AIABewCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAJo--bYDAAAAb-wCAAV2SgAAlV8BAFJfAQCe7AIABewCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 63 kg/st; STABU2: 43.31.10; dagmaatlengte: 1000 mm; lengte: 1135 mm; brandwerendheid E: 120 min; NAA.K.T: samengesteld_product_kozijn; breedte: 1135 mm; Rc-waarde: 0 m²·k/w; serie: BV-F90; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: 110; dagmaatbreedte: 1000 mm; omranding: staal; luik: staal
