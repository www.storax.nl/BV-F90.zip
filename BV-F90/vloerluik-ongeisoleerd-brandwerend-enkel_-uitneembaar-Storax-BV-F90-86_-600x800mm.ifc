Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 377d3a96-b4a5-4887-8926-5a55525e62d5.ifc
Time: 2026-08-11T11:30:59
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd brandwerend enkel, uitneembaar Storax - BV-F90 86, 600x800mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 120 min; Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAJo8_rYDAAAAb-wCAAV2SgAAlV8BAFJfAQCe7AIAB-sCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAJo8_rYDAAAAb-wCAAV2SgAAlV8BAFJfAQCe7AIAB-sCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 38 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 735 mm; brandwerendheid E: 120 min; NAA.K.T: samengesteld_product_kozijn; breedte: 935 mm; Rc-waarde: 0 m²·k/w; serie: BV-F90; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: 86; dagmaatbreedte: 800 mm; omranding: staal; luik: staal
