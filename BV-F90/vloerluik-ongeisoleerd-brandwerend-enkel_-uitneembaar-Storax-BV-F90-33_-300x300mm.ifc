Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 93609f3b-71dd-4df8-a21f-ed20acf8094c.ifc
Time: 2026-08-11T11:26:52
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd brandwerend enkel, uitneembaar Storax - BV-F90 33, 300x300mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 120 min; Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAJqR_rYDAAAAb-wCAAV2SgAAlV8BAFJfAQCe7AIAqusCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAJqR_rYDAAAAb-wCAAV2SgAAlV8BAFJfAQCe7AIAqusCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 13 kg/st; STABU2: 43.31.10; dagmaatlengte: 300 mm; lengte: 435 mm; brandwerendheid E: 120 min; NAA.K.T: samengesteld_product_kozijn; breedte: 435 mm; Rc-waarde: 0 m²·k/w; serie: BV-F90; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: 33; dagmaatbreedte: 300 mm; omranding: staal; luik: staal
