Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 803edf0b-9fdb-4d29-b51a-b89a77c26037.ifc
Time: 2026-08-11T11:32:11
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd brandwerend enkel, uitneembaar Storax - BV-F90 106, 600x1000mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 120 min; Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAJpa-bYDAAAAb-wCAAV2SgAAlV8BAFJfAQCe7AIAYewCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAJpa-bYDAAAAb-wCAAV2SgAAlV8BAFJfAQCe7AIAYewCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 45 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 735 mm; brandwerendheid E: 120 min; NAA.K.T: samengesteld_product_kozijn; breedte: 1135 mm; Rc-waarde: 0 m²·k/w; serie: BV-F90; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: 106; dagmaatbreedte: 1000 mm; omranding: staal; luik: staal
