Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 0f5512bd-f06f-4a19-827b-a446a7d0daad.ifc
Time: 2026-08-11T11:28:25
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd brandwerend enkel, uitneembaar Storax - BV-F90 64, 400x600mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - brandwerendheid E: 120 min; Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAJoN-bYDAAAAb-wCAAV2SgAAlV8BAFJfAQCe7AIANuwCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAJoN-bYDAAAAb-wCAAV2SgAAlV8BAFJfAQCe7AIANuwCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 23 kg/st; STABU2: 43.31.10; dagmaatlengte: 400 mm; lengte: 535 mm; brandwerendheid E: 120 min; NAA.K.T: samengesteld_product_kozijn; breedte: 735 mm; Rc-waarde: 0 m²·k/w; serie: BV-F90; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; type: 64; dagmaatbreedte: 600 mm; omranding: staal; luik: staal
